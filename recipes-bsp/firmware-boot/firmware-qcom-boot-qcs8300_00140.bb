require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "5c17689bdee8793f58e68ebc077e2508555a4ccce601a3c2dc8c68f6267931d3"
SRC_URI[bootbinaries-immutable.sha256sum] = "f6ddfaa62f19e9a6d944c7f01d1aa5a7dee05f3cb66d9b20970b3834b15ee61e"
