require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "48f5a141cd8fa620a1869a5b8a0c2b4ec9db5f7bf06d03c84a1b5a4a33a4a135"
SRC_URI[bootbinaries-immutable.sha256sum] = "91425b049945911f1c11a4652fb1f1c3309e174e650b55d0790f5cad61803bea"
