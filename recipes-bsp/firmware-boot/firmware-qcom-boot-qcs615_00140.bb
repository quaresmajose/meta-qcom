require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "f27bf162caa0dd6e80d0ba3e86b4afecb8fc4cfa9ad1578174d89a2f7ec46d3a"
