require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "8c3f95c0f87305cf0ed88152a9d3bddd30c1757392fe1cc005203a7f2a60dcd3"
SRC_URI[bootbinaries-immutable.sha256sum] = "6b1427b865121966061671d4a1743a87935f5c6132d67bf09d3f3b79b9cd15b4"
