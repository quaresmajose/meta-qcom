require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "38bb3cfb8b4c810a5476d2d6613f40e758ee070759035b553992047a68c7bdd5"
SRC_URI[bootbinaries-immutable.sha256sum] = "389a4a0ff56daf2811d790d2062f97a9b2dfcb32a2c82dfaf324ff7801d98a03"
